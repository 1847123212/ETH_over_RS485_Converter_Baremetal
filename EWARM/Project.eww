<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ETH_RS485_Networkbridge.ewp</path>
  </project>
  <batchBuild />
</workspace>
